# Keil uVision project TaskCreat.uvprojx, settings and files
target TaskCreat (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\MALLOC;..\HARDWARE\EXTI;..\HARDWARE\RC522;..\HARDWARE\ESP8266;..\HARDWARE\USART3;..\HARDWARE\LCD\TOUCH;..\HARDWARE\LCD\TEXT;..\HARDWARE\LCD\MALLOC;..\HARDWARE\LCD\W25QXX;..\HARDWARE\LCD\FATFS\src;..\HARDWARE\LCD\SDIO;..\HARDWARE\LCD\USMART;..\HARDWARE\LCD\24CXX;..\HARDWARE\LCD\IIC;..\HARDWARE\RC522;..\HARDWARE\LCD\USMART;..\HARDWARE\LCD\FATFS\exfuns;..\HARDWARE\LCD\BJDJ;..\HARDWARE\LCD\SPI;..\HARDWARE\PWM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LCD/MALLOC/: malloc.c
    ../HARDWARE/LCD/W25QXX/: w25qxx.c
    ../HARDWARE/LCD/24CXX/: 24cxx.c
    ../HARDWARE/LCD/IIC/: myiic.c
    ../HARDWARE/LCD/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/LCD/SDIO/: sdio_sdcard.c
    ../HARDWARE/LCD/BJDJ/: bjdj.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LCD/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_dma.c
  group README
    ../: README.TXT
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group RC522
    ../HARDWARE/RC522/: rc522.c
  group ESP8266
    ../HARDWARE/ESP8266/: esp8266.c
  group USART3
    ../HARDWARE/USART3/: usart3.c
  group FATFS
    ../HARDWARE/LCD/FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../HARDWARE/LCD/FATFS/src/: diskio.c ff.c
  group USMART
    ../HARDWARE/LCD/USMART/: usmart.c usmart_config.c usmart_str.c
  group TEXT
    ../HARDWARE/LCD/TEXT/: fontupd.c text.c
  group PWM
    ../HARDWARE/PWM/: pwm.c
